# Keil uVision project stm32-7segment-lcd.uvprojx, settings and files
target stm32-7segment-lcd (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L152C6 STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x8007FFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32-7segment-lcd +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L152xB,USE_HAL_DRIVER,STM32L152xB
  c include: ../Inc;                                                                              ../Drivers/STM32L1xx_HAL_Driver/Inc;                                                                              ../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;                                                                              ../Drivers/CMSIS/Device/ST/STM32L1xx/Include;                                                                              ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Application/MDK-ARM
    ./: startup_stm32l152xb.s
  group Application/User
    ../Src/: lcd_ti8077.c bmp085.c button.c main.c stm32l1xx_it.c stm32l1xx_hal_msp.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_i2c.c stm32l1xx_hal_lcd.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_dma.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_cortex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l1xx.c
software components: CMSIS:CORE 4.3.0
